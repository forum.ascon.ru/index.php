# KOMPAS-3D assembly (ｯ｢506.a3d)

Referenced files in C:\Documents and Settings\ASUS\Рабочий стол\лист просечной\: пв506(1).m3d, пв506(2).m3d
Texts:
  пв506