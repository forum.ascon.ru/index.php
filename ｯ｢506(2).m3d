# KOMPAS-3D part (ｯ｢506(2).m3d)

Model tree:
1. Операция без истории:1

Texts:
  пв506(2)