# KOMPAS-3D part (鐘ｨ皹ｮ皸｡ｫ･ｭｨ･ 2_1.m3d)

Model tree:
1. Эскиз:1
2. Операция выдавливания:1
     Расстояние 1 = 10

Texts:
  danilov_321@hotmail.com